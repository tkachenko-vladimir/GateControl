# IAR project mw_bmp085.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S105C6 STM8S105C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8_IAR; STM8_BASE
  ICCSTM8.CCIncludePath2: D:\Dropbox\STM8\Vorota; D:\Dropbox\osa; D:\Dropbox\STM8\PFLIB
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: mw_bmp085.hex
  ILINK.IlinkOutputFile: mw_bmp085.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  ICCSTM8.CCDefines: NDEBUG
  ICCSTM8.CCIncludePath2: D:\Dropbox\STM8\rfm73_tst1\mw_bmp085; D:\Dropbox\osa; D:\Dropbox\STM8\MYLIB; D:\Dropbox\STM8\PFLIB
  group (top)
    ./: init.c main.c
    ../../osa/: osa.c
    ../../osa/port/stm8/: osa_stm8_iar.s
  group PFLIB
    ../PFLIB/: stm8s_adc1.c stm8s_clk.c
